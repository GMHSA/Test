# Keil uVision project BA_balancing.uvprojx, settings and files
target V5.1_Stepper (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Exe
  c flags: Optim=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: C:\Keil\stm32vldiscovery_package\Libraries\STM32F10x_StdPeriph_Driver\inc;C:\Keil\stm32vldiscovery_package\Utilities;..\V5.1_Stepper;..\Hauptprogramm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Files
    ./: system_stm32f10x.c startup_stm32f10x_md.s
  group Source Files
    ./: I2C.c kalman.c balancing.c
  group Library Files
    ./: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
